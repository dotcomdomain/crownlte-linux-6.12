// SPDX-License-Identifier: GPL-2.0
/* Actual crownlte live DT resources. Disabled until firmware bring-up. */
#include <dt-bindings/clock/exynos9810.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/soc/samsung,exynos-usi.h>
/ {
	/*
	 * BCM4361 Wi-Fi power and host wake (4.9 wlan "samsung,brcm-wlan":
	 * gpios = <gpg0 5>, <gpa0 7>). WLAN_REG_ON is driven high before the
	 * PCIe link is trained, exactly as 4.9 dhd_wlan_init_gpio(). Disabled:
	 * see Documentation/crownlte/wifi-port.md.
	 */
	wlan: wlan {
		compatible = "samsung,brcm-wlan";
		wlan-reg-on-gpios = <&gpg0 5 GPIO_ACTIVE_HIGH>;
		wlan-host-wake-gpios = <&gpa0 7 GPIO_ACTIVE_HIGH>;
		pinctrl-names = "default";
		pinctrl-0 = <&cfg_wlanen &wlan_host_wake>;
		status = "disabled";
	};

	/*
	 * S2MPS18 main PMIC (4.9: speedy@141C0000/s2mps18mfd@00 with
	 * acpm-ipc-channel = <2>). Every register access is an ACPM channel-2
	 * request; the APM firmware drives SPEEDY. Read-only unless
	 * samsung,rtc-read-latch / samsung,rtc-write-enable open the RTC block
	 * (never TOP/PMIC). PMIC IRQ = gpa0-1 (4.9 s2mps18,irq-gpio), unused.
	 */
	s2mps18_pmic: s2mps18-pmic {
		compatible = "samsung,exynos9810-s2mps18-acpm";
		acpm-ipc-channel = <2>;
		status = "disabled";
	};
	/* Original crownlte S2MPS18 firmware transport channel, not an I2C device. */
	legacy_acpm_pmic: acpm-pmic-client {
		compatible = "samsung,exynos9810-acpm-pmic-client";
		acpm-ipc-channel = <2>;
		status = "disabled";
	};
	legacy_cmu_ewf: cmu-ewf@1a240000 {
		compatible = "samsung,exynos-cmuewf";
		reg = <0 0x1a240000 0x1000>;
		status = "disabled";
	};
	legacy_osc: exynos9810-oscclk {
		compatible = "samsung,exynos9810-oscclk";
		clock-frequency = <26000000>;
	};
	legacy_cmu: clock-controller@15a80000 {
		compatible = "samsung,exynos9810-clock";
		reg = <0 0x15a80000 0x8000>;
		#clock-cells = <1>;
		status = "disabled";
	};
	legacy_acpm: acpm@14020000 {
		compatible = "samsung,exynos-acpm";
		reg = <0 0x14020000 0x1000>;
		reg-names = "timer_apm";
		acpm-ipc-channel = <4>;
		fvmap_offset = <0x6700>;
		peritimer-cnt = <0xffff>;
		status = "disabled";
	};
	legacy_acpm_ipc: acpm-ipc@14100000 {
		compatible = "samsung,exynos-acpm-ipc";
		reg = <0 0x14100000 0x1000>, <0 0x02039000 0x30000>;
		interrupt-parent = <&gic>;
		interrupts = <GIC_SPI 68 IRQ_TYPE_LEVEL_HIGH>;
		initdata-base = <0x7f00>;
		dump-base = <0x0203c000>;
		dump-size = <0x1d000>;
		logging-period = <500>;
		num-timestamps = <32>;
		debug-log-level = <0>;
		status = "disabled";
	};
	legacy_acpm_dvfs: acpm-dvfs {
		compatible = "samsung,exynos-acpm-dvfs";
		acpm-ipc-channel = <5>;	/* firmware MIF-floor notifications */
		status = "disabled";

		command {
			acpm-ipc-channel = <0>;	/* FREQ_REQ/FREQ_GET/MARGIN_REQ, as 4.9 */
		};
	};

	/*
	 * MIF/INT bus DVFS, from 4.9 crownlte_eur_open_26 devfreq_mif@17000010
	 * and devfreq_int@17000020 (gov_name "interactive", use_acpm, no PPMU).
	 * samsung,freq-info is 4.9 freq_info verbatim, in kHz:
	 *   <initial default-floor suspend min max reboot>
	 * CAL's boot and resume rates replace initial/suspend, as in 4.9.
	 * samsung,boot-qos is 4.9 boot_info <seconds kHz>; MIF down-delay is
	 * delay_time_list. acpm-ipc-channel is the firmware FVP channel used
	 * for the MIF->INT table upload and the sleep RELEASE flag.
	 * CPU/GPU/display consumers raise floors with dev_pm_qos
	 * DEV_PM_QOS_MIN_FREQUENCY on these devices, e.g. a cpufreq node with
	 * samsung,mif-devfreq = <&legacy_devfreq_mif>.
	 */
	legacy_devfreq_mif: devfreq-mif {
		compatible = "samsung,exynos9810-acpm-devfreq";
		samsung,devfreq-type = <0>;		/* 4.9 DEVFREQ_MIF */
		samsung,cal-id = <0x0b040000>;		/* dvfs_mif, 4.9 dfs_id */
		samsung,ect-domain = "dvfs_mif";
		samsung,freq-info = <2093000 208000 1014000 208000 2093000 2093000>;
		samsung,boot-qos = <40 1794000>;
		samsung,down-delay-ms = <20>;
		acpm-ipc-channel = <1>;
		samsung,fvp-constraint-upload;
		samsung,acpm-mif-notify;
		samsung,dependent-devfreq = <&legacy_devfreq_int>;
		status = "disabled";
	};

	legacy_devfreq_int: devfreq-int {
		compatible = "samsung,exynos9810-acpm-devfreq";
		samsung,devfreq-type = <1>;		/* 4.9 DEVFREQ_INT */
		samsung,cal-id = <0x0b040001>;		/* dvfs_int, 4.9 dfs_id */
		samsung,ect-domain = "dvfs_int";
		samsung,freq-info = <667000 178000 107000 107000 667000 667000>;
		samsung,boot-qos = <40 667000>;
		acpm-ipc-channel = <1>;
		status = "disabled";
	};
};

/ {
	/*
	 * Trustonic Kinibi TEE (4.9 exynos9810-crownlte_eur_open_26.dts:10318
	 * "tee" node): S-SIQ notification interrupt SPI 233. 4.9 has flags 0
	 * and the driver requests it IRQF_TRIGGER_RISING; 6.12 irq-gic WARNs on
	 * IRQ_TYPE_NONE (q29, irq-gic.c:1114), so the DT states the rising edge
	 * that request_irq() programs anyway (same GICD_ICFGR value). Probing this
	 * node starts the TEE MCI exactly like the 4.9 boot (MEM_TRACE, INIT,
	 * N_SIQ, INFO/YIELD poll, MCP GET_MOBICORE_VERSION, SWAP_CPU to CPU1).
	 * No TA is loaded and nothing touches secure storage until a userspace
	 * daemon opens /dev/mobicore. Do NOT add 4.9 "ufs-srpmb" (SPI 460, the
	 * RPMB relay for the secure world) or "seclog" here.
	 */
	trustonic_tee: tee {
		compatible = "samsung,exynos-tee";
		interrupts = <GIC_SPI 233 IRQ_TYPE_EDGE_RISING>;
		status = "disabled";
	};
};

/*
 * Touchscreen bus: PERIC0 USI03 as HSI2C (4.9 alias hsi2c10 = hsi2c@104B0000,
 * SPI 404, pins gpp1-4/gpp1-5 function 2, clocks rate 224 = USI03 and
 * gate 205 = GATE_USI03, fast mode 400 kHz default). The USI03 protocol
 * selector is PERIC0 SYSREG +0x101c (4.9 usi@1041101C usi_v2_mode "i2c",
 * value I2C_SW_CONF = BIT(2)). 4.9 also set samsung,stop-after-trans and
 * samsung,reset-before-trans on this bus; the touch driver reproduces the
 * former by issuing opcode and data as separate transfers.
 */
/* 4.9 pcie0 pins; PERST# is gpf2-2, driven high to release the endpoint */
&pcie0 {
	perst-gpios = <&gpf2 2 GPIO_ACTIVE_HIGH>;
	pinctrl-names = "default", "idle";
	pinctrl-0 = <&pcie0_clkreq &pcie0_perst &pcie_wake>;
	pinctrl-1 = <&pcie0_perst &pcie_wake>;
};

&pinctrl_fsys1 {
	pcie0_clkreq: pcie0-clkreq-pins {
		samsung,pins = "gpf2-0";
		samsung,pin-function = <2>;
		samsung,pin-pud = <3>;
		samsung,pin-drv = <3>;
		samsung,pin-con-pdn = <3>;
		samsung,pin-pud-pdn = <3>;
	};

	pcie0_perst: pcie0-perst-pins {
		samsung,pins = "gpf2-2";
		samsung,pin-function = <1>;
		samsung,pin-drv = <3>;
		samsung,pin-con-pdn = <3>;
	};
};

/* alive banks have no power-down config fields on 6.12: 4.9 *-pdn dropped */
&pinctrl_alive {
	pcie_wake: pcie-wake-pins {
		samsung,pins = "gpa3-2";
		samsung,pin-function = <0>;
		samsung,pin-pud = <0>;
	};

	wlan_host_wake: wlan-host-wake-pins {
		samsung,pins = "gpa0-7";
		samsung,pin-function = <15>;
		samsung,pin-pud = <1>;
	};
};

&pinctrl_peric0 {
	cfg_wlanen: cfg-wlanen-pins {
		samsung,pins = "gpg0-5";
		samsung,pin-function = <1>;
		samsung,pin-pud = <0>;
		samsung,pin-drv = <3>;
		samsung,pin-con-pdn = <3>;
	};

	hsi2c10_bus: hsi2c10-bus-pins {
		samsung,pins = "gpp1-4", "gpp1-5";
		samsung,pin-function = <2>;
		samsung,pin-pud = <0>;
		samsung,pin-drv = <0>;
	};
};

/* 4.9 attn-irq "on_state": gpa1-0 EINT, no pull, drive 0. */
&pinctrl_alive {
	touch_irq: touch-irq-pins {
		samsung,pins = "gpa1-0";
		samsung,pin-function = <0xf>;
		samsung,pin-pud = <0>;
		samsung,pin-drv = <0>;
	};
};

&soc {
	usi_peric0_03_sysreg: syscon@1041101c {
		compatible = "samsung,exynos9810-peric0-usi-sysreg", "syscon";
		reg = <0x1041101c 0x4>;
	};

	usi_touch: usi@104b00c0 {
		compatible = "samsung,exynos9810-usi";
		/* Wrapper owns +0xc4/+0xc8; the HSI2C below owns [0, 0xc0). */
		reg = <0x104b00c0 0x20>;
		clocks = <&legacy_cmu GATE_USI03>, <&legacy_cmu USI03>;
		clock-names = "pclk", "ipclk";
		samsung,sysreg = <&usi_peric0_03_sysreg 0>;
		samsung,mode = <USI_V2_I2C>;
		samsung,clkreq-on;
		#address-cells = <1>;
		#size-cells = <1>;
		ranges;
		status = "disabled";

		hsi2c_touch: i2c@104b0000 {
			compatible = "samsung,exynos9810-hsi2c";
			reg = <0x104b0000 0xc0>;
			interrupts = <GIC_SPI 404 IRQ_TYPE_LEVEL_HIGH>;
			#address-cells = <1>;
			#size-cells = <0>;
			clocks = <&legacy_cmu USI03>, <&legacy_cmu GATE_USI03>;
			clock-names = "hsi2c", "hsi2c_pclk";
			clock-frequency = <400000>;
			pinctrl-names = "default";
			pinctrl-0 = <&hsi2c10_bus>;
			status = "disabled";

			/*
			 * 4.9 touchscreen@48 "sec,sec_ts": sec,irq_gpio gpa1-0,
			 * sec,irq_type 0x2008 (level low, oneshot), supplies
			 * S2MPS18 LDO35 "tsp_io" 1.8 V and LDO43 "tsp_avdd"
			 * 3.0 V (both regulator-boot-on). No supplies here:
			 * there is no regulator driver, the bootloader must
			 * leave the IC powered. Never flashes firmware.
			 */
			touchscreen: touchscreen@48 {
				compatible = "samsung,sec-ts-y771";
				reg = <0x48>;
				interrupt-parent = <&gpa1>;
				interrupts = <0 IRQ_TYPE_LEVEL_LOW>;
				irq-gpios = <&gpa1 0 GPIO_ACTIVE_LOW>;
				pinctrl-names = "default";
				pinctrl-0 = <&touch_irq>;
				touchscreen-size-x = <1440>;
				touchscreen-size-y = <2960>;
				status = "disabled";
			};
		};
	};
};

/*
 * Bluetooth (BCM4361 BT core, Documentation/crownlte/bluetooth-port.md).
 * 4.9: /bluetooth "samsung,bcm43xx", gpios = <expander 7>, <gpg2 0>,
 * <gpa2 3> (bt_en, bt_wake, bt_hostwake); BT UART uart@10840000 = ttySAC1;
 * expander pcal6524@22 on hsi2c@10930000 (USI10_I2C).
 *
 * BT_REG_ON is P0_7 of that PCAL6524, which also drives NFC VEN (P1_3),
 * wireless charging wpc_en (P1_0) and the DP switch (P0_1, P0_4). No GPIO
 * driver binds to it (GPIO_PCA953X stays off, the bluetooth driver refuses
 * to touch it if any driver is bound); the bluetooth driver only does
 * read-modify-write of bit 7 in output/configuration port 0. No reset-gpios:
 * the expander reset (gpg3-6) is never driven by 6.12.
 *
 * Node name "bluetooth" is fixed: vendor sepolicy labels
 * /sys/devices/platform/bluetooth/rfkill/rfkill0/state and the vendor rc
 * chowns rfkill0. The serial1 alias makes the UART ttySAC1 (libbt opens
 * /dev/ttySAC1). Everything is disabled here; diagnostic DTBs enable it.
 */
/ {
	aliases {
		serial1 = &serial_bt;
	};

	bluetooth: bluetooth {
		compatible = "samsung,bcm43xx";
		samsung,bt-reg-on-expander = <&bt_expander>;	/* P0_7, fixed */
		samsung,bt-uart = <&serial_bt>;
		bt-wake-gpios = <&gpg2 0 GPIO_ACTIVE_HIGH>;
		bt-host-wake-gpios = <&gpa2 3 GPIO_ACTIVE_HIGH>;
		pinctrl-names = "default";
		pinctrl-0 = <&bt_hostwake &bt_btwake>;
		status = "disabled";
	};
};

/* alive banks have no power-down config fields on 6.12: 4.9 *-pdn dropped */
&pinctrl_alive {
	uart_bt_bus: uart-bt-bus-pins {
		samsung,pins = "gpq0-3", "gpq0-2", "gpq0-1", "gpq0-0";
		samsung,pin-function = <2>;
		samsung,pin-pud = <3>;
		samsung,pin-drv = <0>;
	};

	bt_hostwake: bt-hostwake-pins {
		samsung,pins = "gpa2-3";
		samsung,pin-function = <0xf>;
		samsung,pin-pud = <0>;
	};
};

&pinctrl_peric0 {
	bt_btwake: bt-btwake-pins {
		samsung,pins = "gpg2-0";
		samsung,pin-function = <1>;
		samsung,pin-pud = <0>;
		samsung,pin-con-pdn = <3>;
		samsung,pin-pud-pdn = <0>;
	};
};

&pinctrl_peric1 {
	hsi2c25_bus: hsi2c25-bus-pins {
		samsung,pins = "gpp6-2", "gpp6-3";
		samsung,pin-function = <3>;
		samsung,pin-pud = <0>;
		samsung,pin-drv = <0>;
	};
};

&soc {
	/*
	 * BT UART (4.9 uart@10840000: SPI 422, clocks GATE_UART_BT + UART_BT,
	 * fifo 256, usi-serial-v2). Fixed-function: no SYSREG SW_CONF; the 4.9
	 * driver pulsed USI_CON reset and set USI_OPTION CLKREQ_ON.
	 */
	usi_uart_bt: usi@108400c0 {
		compatible = "samsung,exynos9810-usi";
		/* Wrapper owns +0xc4/+0xc8; the UART below owns [0, 0xc0). */
		reg = <0x108400c0 0x20>;
		clocks = <&legacy_cmu GATE_UART_BT>, <&legacy_cmu UART_BT>;
		clock-names = "pclk", "ipclk";
		samsung,mode = <USI_V2_UART>;
		samsung,no-sw-conf;
		samsung,clkreq-on;
		#address-cells = <1>;
		#size-cells = <1>;
		ranges;
		status = "disabled";

		serial_bt: serial@10840000 {
			compatible = "samsung,exynos9810-uart";
			reg = <0x10840000 0xc0>;
			interrupts = <GIC_SPI 422 IRQ_TYPE_LEVEL_HIGH>;
			clocks = <&legacy_cmu GATE_UART_BT>, <&legacy_cmu UART_BT>;
			clock-names = "uart", "clk_uart_baud0";
			samsung,uart-fifosize = <256>;
			pinctrl-names = "default";
			pinctrl-0 = <&uart_bt_bus>;
			status = "disabled";
		};
	};

	/*
	 * Expander bus: USI10_I2C (4.9 hsi2c@10930000, alias hsi2c25, SPI 437,
	 * clocks PERIC1_USI_I2C + GATE_USI10_I2C, default-clk 200 MHz, fast
	 * mode). 4.9 never wrote a SW_CONF for it (usi@10811040 disabled); the
	 * hsi2c driver only cleared USI_CON reset.
	 */
	usi_i2c_exp: usi@109300c0 {
		compatible = "samsung,exynos9810-usi";
		reg = <0x109300c0 0x20>;
		clocks = <&legacy_cmu GATE_USI10_I2C>, <&legacy_cmu PERIC1_USI_I2C>;
		clock-names = "pclk", "ipclk";
		samsung,mode = <USI_V2_I2C>;
		samsung,no-sw-conf;
		#address-cells = <1>;
		#size-cells = <1>;
		ranges;
		status = "disabled";

		hsi2c_exp: i2c@10930000 {
			compatible = "samsung,exynos9810-hsi2c";
			reg = <0x10930000 0xc0>;
			interrupts = <GIC_SPI 437 IRQ_TYPE_LEVEL_HIGH>;
			#address-cells = <1>;
			#size-cells = <0>;
			clocks = <&legacy_cmu PERIC1_USI_I2C>, <&legacy_cmu GATE_USI10_I2C>;
			clock-names = "hsi2c", "hsi2c_pclk";
			clock-frequency = <400000>;	/* 4.9 fast-mode default */
			pinctrl-names = "default";
			pinctrl-0 = <&hsi2c25_bus>;
			status = "disabled";

			/* no reset-gpios, no interrupts, no GPIO driver: see above */
			bt_expander: gpio@22 {
				compatible = "nxp,pcal6524";
				reg = <0x22>;
				gpio-controller;
				#gpio-cells = <2>;
				status = "disabled";
			};
		};
	};
};
 		};
 	};
 };

/*
 * Amplifier bus: PERIC1 USI07 as HSI2C (4.9 alias hsi2c18 = hsi2c@108C0000,
 * SPI 430, pins gpp4-4/gpp4-5 function 2 no pull, clocks rate 275 = USI07
 * and gate 251 = GATE_USI07, 4.9 default fast mode 400 kHz). The USI07
 * protocol selector is PERIC1 SYSREG +0x1024 (4.9 usi@10811024 usi_v2_mode
 * "i2c"). 4.9 children: max98512@39 (left, earpiece in receiver mode) with
 * maxim,sub_reg = 0x3a (right, bottom speaker).
 * No child node here on purpose: the MAX98512 driver writes boost,
 * brownout and gain registers at probe (audio-design.md 4.1); the amps
 * stay unbound until stage A6 [owner gates G3/G4]. Disabled; the audio A1
 * DTB enables the bus for read-only register reads.
 */
&pinctrl_peric1 {
	hsi2c18_bus: hsi2c18-bus-pins {
		samsung,pins = "gpp4-4", "gpp4-5";
		samsung,pin-function = <2>;
		samsung,pin-pud = <0>;
		samsung,pin-drv = <0>;
	};
};

&soc {
	usi_peric1_07_sysreg: syscon@10811024 {
		compatible = "samsung,exynos9810-peric1-usi-sysreg", "syscon";
		reg = <0x10811024 0x4>;
	};

	usi_amp: usi@108c00c0 {
		compatible = "samsung,exynos9810-usi";
		/* Wrapper owns +0xc4/+0xc8; the HSI2C below owns [0, 0xc0). */
		reg = <0x108c00c0 0x20>;
		clocks = <&legacy_cmu GATE_USI07>, <&legacy_cmu USI07>;
		clock-names = "pclk", "ipclk";
		samsung,sysreg = <&usi_peric1_07_sysreg 0>;
		samsung,mode = <USI_V2_I2C>;
		samsung,clkreq-on;
		#address-cells = <1>;
		#size-cells = <1>;
		ranges;
		status = "disabled";

		hsi2c_amp: i2c@108c0000 {
			compatible = "samsung,exynos9810-hsi2c";
			reg = <0x108c0000 0xc0>;
			interrupts = <GIC_SPI 430 IRQ_TYPE_LEVEL_HIGH>;
			#address-cells = <1>;
			#size-cells = <0>;
			clocks = <&legacy_cmu USI07>, <&legacy_cmu GATE_USI07>;
			clock-names = "hsi2c", "hsi2c_pclk";
			clock-frequency = <400000>;
			pinctrl-names = "default";
			pinctrl-0 = <&hsi2c18_bus>;
			status = "disabled";
		};
	};
};

/*
 * ABOX audio DSP, audio stage A2 (Documentation/crownlte/audio-a2.md):
 * firmware boot test only, everything disabled here. 4.9 nodes:
 * abox@17C50000 (sfr, sysreg 0x17C10000, sram 0x17D00000 0x31000; IPC
 * tx 0x30000, rx 0x30300, tx_ack 0x302FC, rx_ack 0x305FC), abox_gic
 * (gicd 0x17CF1000, gicc 0x17CF2000, SPI 76 rising), sysmmu@17E00000
 * (SPI 79, qos 15, port "Abox"), clocks pll/cpu/audif/dmic/bus =
 * PLL_OUT_AUD/GATE_ABOX_DUMMY/DOUT_CLK_ABOX_AUDIF/DOUT_CLK_ABOX_DMIC/
 * DOUT_CLK_ABOX_ACLK. All of them are inside pd-aud: the SysMMU and the
 * ABOX only probe after the A2 gate (samsung,abox-a2-guard) armed the
 * watchdog deadline, saw AUD_STATUS on and took the AUD clocks.
 */
/ {
	abox_a2: abox-a2 {
		compatible = "samsung,exynos9810-abox-a2";
		samsung,pmu-syscon = <&pmu_system_controller>;
		clocks = <&legacy_cmu PLL_OUT_AUD>, <&legacy_cmu GATE_ABOX_DUMMY>,
			 <&legacy_cmu DOUT_CLK_ABOX_AUDIF>, <&legacy_cmu DOUT_CLK_ABOX_DMIC>,
			 <&legacy_cmu DOUT_CLK_ABOX_ACLK>;
		clock-names = "pll", "cpu", "audif", "dmic", "bus";
		status = "disabled";
	};
};

&soc {
	sysmmu_abox: sysmmu@17e00000 {
		compatible = "samsung,exynos9810-sysmmu", "samsung,exynos-sysmmu";
		reg = <0x17e00000 0x9000>;
		interrupts = <GIC_SPI 79 IRQ_TYPE_LEVEL_HIGH>;
		samsung,qos = <15>;
		samsung,pmu-syscon = <&pmu_system_controller>;
		samsung,pd-status = <0x4004 0xf 0xf>;
		samsung,abox-a2-guard = <&abox_a2>;
		#iommu-cells = <0>;
		status = "disabled";
	};

	abox: abox@17c50000 {
		compatible = "samsung,exynos9810-abox-boot";
		reg = <0x17c50000 0x10000>, <0x17c10000 0x10000>,
		      <0x17d00000 0x31000>, <0x17cf1000 0x1000>,
		      <0x17cf2000 0x1004>;
		reg-names = "sfr", "sysreg", "sram", "gicd", "gicc";
		interrupts = <GIC_SPI 76 IRQ_TYPE_EDGE_RISING>;
		iommus = <&sysmmu_abox>;
		samsung,abox-a2-guard = <&abox_a2>;
		samsung,ipc-tx-offset = <0x30000>;
		samsung,ipc-rx-offset = <0x30300>;
		samsung,ipc-tx-ack-offset = <0x302fc>;
		samsung,ipc-rx-ack-offset = <0x305fc>;
		/* 4.9 ext_bin@0..6, all area 1 (DRAM image) */
		samsung,ext-firmware-names = "dsm.bin", "AP_AUDIO_SLSI.bin",
			"APBargeIn_AUDIO_SLSI.bin", "SoundBoosterParam.bin",
			"APDV_AUDIO_SLSI.bin", "APBiBF_AUDIO_SLSI.bin", "dsm_tune.bin";
		samsung,ext-firmware-offsets = <0x502000 0x7e0000 0x7dc000 0x4fc000
						0x4d0000 0x7df000 0x601000>;
		status = "disabled";
	};
};
